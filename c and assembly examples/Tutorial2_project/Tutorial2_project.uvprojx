# Keil uVision project Tutorial2_project.uvprojx, settings and files
target Application (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Tutorial2_project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: example1_c.c example2_c.c example3_c.c example4_c.c example5_c.c example6_c.c example7_c.c example8_c.c main.c
  group asm
    ./asm/: example1_asm.s example2_asm.s example3_asm.s example4_asm.s example5_asm.s example6_asm.s example7_asm.s example8_asm.s
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, Compiler:I/O:STDOUT 1.1.0, Device:Startup 2.5.0
